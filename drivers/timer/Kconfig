## drivers/timer/Kconfig
```kconfig
config AXITIMER
	tristate "AxiTimer Module"
	depends on ARM
	default y if ARM
	help
		Axitimer Module
```
